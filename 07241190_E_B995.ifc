Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 2b8e9b8b-ada7-4bfc-af82-b842e07dc457, NumberOfSaves: 1]
File name: 0001
Time: 2024-08-15T10:24:02+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 07241190_E_B995:13099502_E_7241190_B995, (2)
In: Default
Type - Material: z_Miele_Design_BRWS, z_Miele_Design_CLST, z_Miele_Connection_Water_IN, <Unnamed>, z_Miele_Connection_Connection_Modul, Roller
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 985 mm; Height: 959 mm; Depth: 380 mm
Classification: E1010620 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 13099502_E_7241190_B995; sets with these values: 2
